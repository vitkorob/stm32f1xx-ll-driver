# IAR project driverlib.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103x6 ST STM32F103x6
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; USE_FULL_ASSERT=1; STM32F103x6; DEBUG
  ICCARM.CCIncludePath2: Include; ..\CMSIS\Include; ..\Device\ST\STM32F1xx\Include
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_FULL_LL_DRIVER=1; STM32F103x6; NDEBUG
  group Code
    Source/: stm32f1xx_ll_adc.c stm32f1xx_ll_crc.c stm32f1xx_ll_dac.c stm32f1xx_ll_dma.c stm32f1xx_ll_exti.c stm32f1xx_ll_gpio.c stm32f1xx_ll_i2c.c stm32f1xx_ll_irq.c stm32f1xx_ll_pwr.c stm32f1xx_ll_rcc.c stm32f1xx_ll_rtc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_usart.c stm32f1xx_ll_utils.c system_stm32f1xx.c
